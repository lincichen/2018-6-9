# Keil uVision project Smpl_Basic01_FMC_AP0_main.uvproj, settings and files
target fmc_ap0_main (ARM-ADS)
  device: M453VG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.6
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: fmc_ap0_main +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: DEBUG_ENABLE_SEMIHOST
  c misc: -L6969W
  c include: ..\..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\NuEdu\inc;.\zmodem
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler --diag_suppress 6969
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group Libraries
    ../../../../Library/StdDriver/src/: retarget.c fmc.c clk.c sys.c gpio.c timer.c uart.c
  group User
    ../: ap0_main.c
    ./: ap0_image.s
    ./zmodem/: FlashProgrammer.c zmodem.c ZmodemCrctab.c ZmodemReceive.c
  group NuEdu
    ../../../../Library/NuEdu/src/: NuEdu-Basic01_LED.c
